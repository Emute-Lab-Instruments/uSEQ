# Repository Emute-Lab-Instruments/uSEQ

File README.md:

# uSEQ

uSEQ is a livecodeable eurorack module.

There's a paper on it here: 

Kyriakoudis, Dimitris, & Kiefer, Chris. (2023, April 19). uSEQ: A LISPy Modular Sequencer for Eurorack with a Livecodable Microcontroller. 7th International Conference on Live Coding (ICLC2023), Utrecht, The Netherlands. https://doi.org/10.5281/zenodo.7843874

uSEQ modules, two panel designs (PCB, Aluminium)

uSEQ modules set up within eurorack performance systems

## Features:

* Open source hardware and software
* Low-cost DIY project
* Live code using a simple LISP language library, from a laptop or mobile device, using serial-over-USB
* Stream waveforms back over USB serial to a computer, and route it to MIDI or OSC, linking the modular with software and external hardware
* Livecoding engine with flexible timing and varied options for creating gate and CV patterns (from basic waveforms to euclidean sequencing) and structuring arrangements

More info from [https://www.emutelabinstruments.co.uk/useq/](https://www.emutelabinstruments.co.uk/useq/)

## Canonical Specs

The firmware/language specs live in [docs/specs/MAIN.md](docs/specs/MAIN.md).
Protocol details live in [docs/specs/wire-protocol.md](docs/specs/wire-protocol.md).
Read [MAP.md](MAP.md) for the repository index and [ALIGNMENT.md](ALIGNMENT.md)
for the dated mission-level gaps.

## Verification

- `nix-shell` enters the declared compiler, conformance, WASM, PlatformIO,
  and RP2040 goal-gate environment. On unattended hosts, use
  `nix-shell --run '<command>'` so PyYAML and the target tools come from the
  same environment.
- `meson setup build && meson compile -C build && meson test -C build` runs
  the native suites.
- `python3 scripts/run_conformance.py --probe build/test/signal_engine_probe --target native`
  runs the shared language corpus against the native probe.
- `scripts/build_wasm.sh` builds and checks the generated interpreter;
  `python3 scripts/run_conformance.py --target wasm` runs the same corpus
  against it; `python3 scripts/wasm_manifest.py verify` verifies its compiler
  record.
- `pio run -e musicthing` establishes target compile, link, and static size;
  it is not a physical-execution result.
- `python3 scripts/rp2040_memory_report.py` reads the exact linked ELF and
  enforces the 96KiB main-heap and 1MiB flash-image headroom gates. Runtime
  heap and stack watermarks remain separate target observations.
- `pio run -e musicthing-observe` builds the release-equivalent telemetry
  image used by simulator and physical-device capacity/endurance runs;
  `musicthing` remains the production image without devtools overhead.
- `python3 scripts/run_rp2040_profile.py` runs the full local RP2040
  acceptance surface: native correctness, constrained-profile conformance,
  capacity and sanitized endurance workloads, both target links, and exact
  ELF memory gates. See
  [docs/testing/rp2040-optimization.md](docs/testing/rp2040-optimization.md).
- `python3 scripts/run_wokwi_rp2040.py` boots that exact observation ELF in
  Wokwi and gates serial responses, target compile and tick timing, runtime
  heap/stack headroom, resource high-water, sustained tick throughput,
  protocol integrity, reset state, retained workload capacity, transactional
  rejection, and externally captured GPIO. It requires `wokwi-cli` and an
  unprinted `WOKWI_CLI_TOKEN`.
- `python3 scripts/run_rp2040_goal_gate.py` composes the complete native,
  exact-link, and simulator grades into one uniquely named candidate evidence
  directory for an optimization loop. Physical-device acceptance remains a
  separate release grade.

## Building the Firmware

The firmware is in the [uSEQ](./uSEQ/) folder.

Build the firmware in Arduino IDE, using the [Earle Philhower Pico core](https://github.com/earlephilhower/arduino-pico).

| Setting  | Value |
| ------------- | ------------- |
| Board  | Generic RP2040  |
| Boot Stage 2  | W25Q080 QSPI /2  |
| Flash Size | 16MB (Sketch 2MB, FS: 14MB) for `musicthing` |
| CPU Speed | 250MHz (Overclock) |
| Optimize | Optimize Even More (-O3) |

Overclock the Pico at 250Mhz and set the optimisation level to -O3.
Other program-card capacities require a matching PlatformIO partition profile;
the default `musicthing` environment is the 16MB card profile.

We welcome pull requests.

## KiCad design hardware/version1.0/useq1/useq1.kicad_pcb

Parts:
C1, C5: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C8: 22u 0805; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4: 22u; C_0805_2012Metric
C6, C7: 1nF; C_0402_1005Metric
C9, C13, C38: 10u; C_0603_1608Metric
C10, C11, C14, C16, C17, C18, C20, C21, C24, C33, C37: 100n; C_0402_1005Metric
C12, C15: 1u; C_0402_1005Metric
C19, C22, C23, C25, C26, C29, C30, C31, C32, C39, C40, C41, C42: 100n; C_0603_1608Metric
C27, C28: 30p; C_0402_1005Metric
C34, C35, C36: 10n; C_0402_1005Metric
D1, D2: 1N4148W; D_SOD-123
D3, D4: 1N5819; D_SOD-323
D5: LED Gate In 1; LED_D3.0mm_FlatTop
D6: LED Gate In 2; LED_D3.0mm_FlatTop
D7: LED A1; LED_D3.0mm_FlatTop
D8: LED A2; LED_D3.0mm_FlatTop
D9: LED CV In 1; LED_D3.0mm_FlatTop
D10: LED CV In 2; LED_D3.0mm_FlatTop
D11: LED A3; LED_D3.0mm_FlatTop
D12: LED D1; LED_D3.0mm_FlatTop
D13: LED D2; LED_D3.0mm_FlatTop
D14: LED D3; LED_D3.0mm_FlatTop
D15: LED Test; LED_0603_1608Metric
FB1, FB2: FerriteBead GZ2012D101TF; R_0805_2012Metric
H1: PIN_HEADER_2x5 POWER; PinHeader_2x05_P2.54mm_Vertical_SMD
J1: Hanbo_USB_C_Receptacle_USB2.0_MC-110LD-L137; USB-C-TH_MC-110LD-L137-A
J2: Gate In 1; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J3: Gate In 2; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J4: CV In 1; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J5: CV In 2; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J7, J8: Conn_02x01; PinHeader_1x02_P2.54mm_Vertical
J9: Out A1; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J10: Out A2; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J11: Out A3; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J12: Out D1; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J13: Out D2; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J14: Out D3; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J15: SWD; PinHeader_1x03_P2.54mm_Vertical
Q1, Q2: MMBT3904; SOT-23; MPN MMBT3904-TP; Digi-Key_PN MMBT3904TPMSCT-ND
R1, R2, R4, R5, R7, R8, R9, R10, R11, R12: 100k; R_0402_1005Metric
R3, R6: 5.1k; R_0402_1005Metric
R13, R14: 33k; R_0402_1005Metric
R15, R66: 1.8, >24mW; R_0603_1608Metric
R16, R17, R19, R20, R67, R68: 5.1k 1%; R_0402_1005Metric
R18: 4.7k; R_0603_1608Metric
R21, R22: 27; C_0402_1005Metric
R23, R24, R33, R34, R35: 18k; R_0603_1608Metric
R25, R26, R27, R28, R32: 9.1k; R_0603_1608Metric
R29, R59, R60, R61, R62, R63, R64: 1k; R_0402_1005Metric
R30: DNF; C_0805_2012Metric
R31, R37, R65: 1.5k; R_0603_1608Metric
R36: 1k; R_0603_1608Metric
R38, R39, R40: 12k; R_0603_1608Metric
R41, R42, R43: 10k; R_0603_1608Metric
R44, R45, R46: 33k; R_0603_1608Metric
R47, R48, R49: 51k; R_0603_1608Metric
R50, R51, R52, R53, R54, R55: 47k; R_0603_1608Metric
R56, R57, R58: 27k; R_0603_1608Metric
RV1, RV2: 100k; Alpha9mmPot
S1, S2: B3U-1000P; Switch_Tactile_SMD_B3U-1000P; MPN B3U-1000P; Digi-Key_PN SW1020CT-ND
SW1: SW_Push; GPBS850N; Mouser Part Number 629-GPBS-850N
SW3: SW_SPDT; Thonk DWB2
TP1: RP2040 Power; TestPoint_Pad_1.5x1.5mm
TP2: Analog Power; TestPoint_Pad_1.5x1.5mm
TP3, TP9: 5V reference; TestPoint_Pad_1.5x1.5mm
TP4: -5V Ref; TestPoint_Pad_1.5x1.5mm
TP5: CVIn; TestPoint_Pad_1.5x1.5mm
TP6: CV Out; TestPoint_Pad_1.5x1.5mm
TP7: Digital Out; TestPoint_Pad_1.5x1.5mm
TP8: 1V1; TestPoint_Pad_1.5x1.5mm
U1, U4: TLV76733DRVR; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm_ThermalVias
U2, U8, U9, U10: TL072; SO-8_3.9x4.9mm_P1.27mm
U3: MCP6002-xMS; MSOP-8_3x3mm_P0.65mm
U5, U6, U12: CJ431 SOT-23; SOT-23
U7: RP2040; RP2040-QFN-56
U11: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
Y1: YXC X322512MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C10.1, C11.1, C12.1, TP8.1, U7.23 (DVDD), U7.45 (VREG_VOUT), U7.50 (DVDD)
+3V3: C2.1, C14.1, C15.1, C16.1, C17.1, C18.1, C20.1, C21.1, C24.1, C33.1, R30.1, R31.2, R37.2, TP1.1, U1.1 (OUT), U1.2 (SNS), U7.1 (IOVDD), U7.10 (IOVDD), U7.22 (IOVDD), U7.33 (IOVDD), U7.42 (IOVDD), U7.44 (VREG_IN), U7.48 (USB_VDD), U7.49 (IOVDD), U11.8 (VCC)
+5V: C9.1, J4.TN, J5.TN, R15.1, R16.1, R50.1, R51.1, TP3.1, U5.2 (K)
+12V: C1.1, C3.1, C5.1, C22.2, C25.2, C29.2, C31.2, C39.1, C41.1, D4.1 (K), R15.2, R66.2, U1.4 (EN), U1.6 (IN), U2.8 (V+), U4.4 (EN), U4.6 (IN), U8.8 (V+), U9.8 (V+), U10.8 (V+)
-5V: C13.1, R9.1, R10.1, R18.1, R19.1, TP4.1, U6.3 (A)
-12V: C4.2, C23.2, C26.2, C30.2, C32.2, C40.2, C42.2, D3.2 (A), R18.2, U2.4 (V-), U8.4 (V-), U9.4 (V-), U10.4 (V-)
/+3V3_SIG: C8.1, C19.2, C37.1, TP2.1, U3.8 (V+), U4.1 (OUT), U4.2 (SNS), U7.43 (ADC_AVDD)
/+5V_B: C38.1, R52.1, R66.1, R67.1, TP9.1, U12.2 (K)
/GPIO0_Ext1: J7.2, J8.2, R31.1, U7.2 (GPIO0)
/GPIO1_Ext2: J7.1, J8.1, R37.1, U7.3 (GPIO1)
/GPIO2_LED_A2: R26.1, U7.4 (GPIO2)
/GPIO3: U7.5 (GPIO3)
/GPIO4_LED_In2: R24.1, U7.6 (GPIO4)
/GPIO5_LED_In1: R23.1, U7.7 (GPIO5)
/GPIO6_LED_CVIn2: R27.1, U7.8 (GPIO6)
/GPIO7_LED_CVIn1: R28.1, U7.9 (GPIO7)
/GPIO8_GateInput1: Q1.3 (C), U7.11 (GPIO8)
/GPIO9_GateInput2: Q2.3 (C), U7.12 (GPIO9)
/GPIO10_SWM: SW1.2 (COM_1), SW1.5 (COM_2), U7.13 (GPIO10)
/GPIO11_LED_A3: R32.1, U7.14 (GPIO11)
/GPIO12_LED_D1: R33.1, U7.15 (GPIO12)
/GPIO13_LED_D2: R34.1, U7.16 (GPIO13)
/GPIO14_LED_A1: R25.1, U7.17 (GPIO14)
/GPIO15_SWT: SW3.1 (A), U7.18 (GPIO15)
/GPIO16_Digital3: TP7.1, U7.27 (GPIO16), U9.5 (+)
/GPIO17_Digital2: U7.28 (GPIO17), U10.5 (+)
/GPIO18_Digital1: U7.29 (GPIO18), U10.3 (+)
/GPIO19_PWM3: R43.1, U7.30 (GPIO19)
/GPIO20_PWM2: R42.1, U7.31 (GPIO20)
/GPIO21_PWM1: R41.1, U7.32 (GPIO21)
/GPIO22_LED_D3: R35.1, U7.34 (GPIO22)
/GPIO23_SWTB: SW3.3 (C), U7.35 (GPIO23)
/GPIO24_TEST_LED: R65.1, U7.36 (GPIO24)
/GPIO25: U7.37 (GPIO25)
/GPIO26_ADC0: C6.1, R13.2, TP5.1, U3.1, U7.38 (GPIO26_ADC0)
/GPIO27_ADC1: C7.1, R14.2, U3.7, U7.39 (GPIO27_ADC1)
/GPIO28_ADC2: U7.40 (GPIO28_ADC2)
/GPIO29_ADC3: U7.41 (GPIO29_ADC3)
/QSPI_SCLK: U7.52 (QSPI_SCLK), U11.6 (CLK)
/QSPI_SD0: U7.53 (QSPI_SD0), U11.5 (DI(IO0))
/QSPI_SD1: U7.55 (QSPI_SD1), U11.2 (DO(IO1))
/QSPI_SD2: U7.54 (QSPI_SD2), U11.3 (IO2)
/QSPI_SD3: U7.51 (QSPI_SD3), U11.7 (IO3)
/QSPI_SS: R29.1, R30.2, U7.56 (QSPI_SS), U11.1 (~CS)
/RUN: S1.2, U7.26 (RUN)
/SWCLK: J15.1, U7.24 (SWCLK)
/SWD: J15.3, U7.25 (SWD)
/USB_D+: J1.A6 (D+), J1.B6 (D+), R21.1
/USB_D-: J1.A7 (D-), J1.B7 (D-), R22.1
/XIN: C27.1, U7.20 (XIN), Y1.1
/XOUT: R36.1, U7.21 (XOUT)
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, C20.2, C21.2, C22.1, C23.1, C24.2, C25.1, C26.1, C27.2, C28.2, C29.1, C30.1, C31.1, C32.1, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.1, C41.2, C42.1, D1.2 (A), D2.2 (A), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), H1.3, H1.4, H1.5, H1.6, H1.7, H1.8, J1.13 (SHIELD), J1.A1B12 (GND), J1.A12B1 (GND), J2.S, J3.S, J4.S, J5.S, J9.S, J10.S, J11.S, J12.S, J13.S, J14.S, J15.2, Q1.2 (E), Q2.2 (E), R3.2, R6.2, R17.2, R20.2, R38.1, R39.1, R40.1, R47.1, R48.1, R49.1, R68.2, S1.1, S2.1, SW1.3 (NO_1), SW1.6 (NO_2), SW3.2 (B), U1.3 (GND), U1.5 (GND), U1.7 (PAD), U2.3 (+), U2.5 (+), U3.3 (+), U3.4 (V-), U3.5 (+), U4.3 (GND), U4.5 (GND), U4.7 (PAD), U5.3 (A), U6.2 (K), U7.19 (TESTEN), U7.57 (GND), U11.4 (GND), U12.3 (A), Y1.2, Y1.4
unnamed: C28.1, R36.2, Y1.3
unnamed: D1.1 (K), Q2.1 (B), R5.1
unnamed: D2.1 (K), Q1.1 (B), R4.1
unnamed: D3.1 (K), FB1.2
unnamed: D4.2 (A), FB2.2
unnamed: D5.2 (A), R23.2
unnamed: D6.2 (A), R24.2
unnamed: D7.2 (A), R25.2
unnamed: D8.2 (A), R26.2
unnamed: D9.2 (A), R27.2
unnamed: D10.2 (A), R28.2
unnamed: D11.2 (A), R32.2
unnamed: D12.2 (A), R33.2
unnamed: D13.2 (A), R34.2
unnamed: D14.2 (A), R35.2
unnamed: D15.2 (A), R65.2
unnamed: FB1.1, H1.9, H1.10
unnamed: FB2.1, H1.1, H1.2
unnamed: J1.A5 (CC1), R6.1
unnamed: J1.B5 (CC2), R3.1
unnamed: J2.T, R4.2
unnamed: J3.T, R5.2
unnamed: J4.T, R1.1
unnamed: J5.T, R2.1
unnamed: J9.T, R59.1
unnamed: J10.T, R60.1
unnamed: J11.T, R61.1
unnamed: J12.T, R62.1
unnamed: J13.T, R63.1
unnamed: J14.T, R64.1
unnamed: R1.2, RV1.2
unnamed: R2.2, RV2.2
unnamed: R7.2, R11.1, U2.1
unnamed: R8.2, R12.1, U2.7
unnamed: R29.2, S2.2
unnamed: R38.2, R44.1
unnamed: R39.2, R45.1
unnamed: R40.2, R46.1
unnamed: R53.2, R59.2, U8.1
unnamed: R54.2, R60.2, U8.7
unnamed: R55.2, R61.2, U9.1
unnamed: R56.2, R62.2, U10.1
unnamed: R57.2, R63.2, U10.7
unnamed: R58.2, R64.2, U9.7
unnamed: R7.1, RV1.3, U2.2 (-)
unnamed: R8.1, RV2.3, U2.6 (-)
unnamed: C6.2, R9.2, R11.2, R13.1, RV1.1, U3.2 (-)
unnamed: C7.2, R10.2, R12.2, R14.1, RV2.1, U3.6 (-)
unnamed: R16.2, R17.1, U5.1 (REF)
unnamed: R19.2, R20.1, U6.1 (REF)
unnamed: R22.2, U7.46 (USB_DM)
unnamed: R21.2, U7.47 (USB_DP)
unnamed: C34.1, R41.2, TP6.1, U8.3 (+)
unnamed: R44.2, R50.2, R53.1, U8.2 (-)
unnamed: C35.1, R42.2, U8.5 (+)
unnamed: R45.2, R51.2, R54.1, U8.6 (-)
unnamed: C36.1, R43.2, U9.3 (+)
unnamed: R46.2, R52.2, R55.1, U9.2 (-)
unnamed: R49.2, R58.1, U9.6 (-)
unnamed: R47.2, R56.1, U10.2 (-)
unnamed: R48.2, R57.1, U10.6 (-)
unnamed: R67.2, R68.1, U12.1 (REF)

Notes on the sheet:
Digital Out
CV Input, scale -5-5 => 0-3.3 with attenverter
shift/scale 0-3-3 -> -5-5
scale 0-3.3 -> 0-5
CV Out
lpf 1.5kHz
lpf 10kHz
Crystal
1mA req
1.5mA req
Extension connector
https://modwiggler.com/forum/viewtopic.php?t=253062 https://electronotes.netfirms.com/AN235.pdf
1.5uA
Make sure R3 and R4 are close to RP2040
note: debouncing not required, bounces will have little effect Can use PIO debounce if necessary
Flash
Left
Make sure C10 is close to pin 44 of RP2040
Make sure C8 is close to pin 45 of RP2040
try https://jlcpcb.com/partdetail/3151464-SX3B12000F1510F30/C2901651
Jan 2024
50uA
uSEQ
-50uA, 250uW
Right

Board: 2 copper layers, 40.6 x 108.0 mm, 172 parts (28 on the bottom side), 110 nets.

## KiCad design hardware/version0.2/kicad/useq.kicad_pcb

Board: 2 copper layers, 40.6 x 108.0 mm, 59 parts (23 on the bottom side), 57 nets.

Parts:
C1: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2: 100n; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C3, C4: 10n; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C5, C6, C7, C8: (10n); C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1, D2, D3, D4, D5: 1N5819; D_SOD-323
D6, D7, D8, D9, D10, D11, D12, D13: LED; LED_D3.0mm
H1: PIN_HEADER_2x8; IDC-Header_2x08_P2.54mm_Vertical
J1, J2, J3, J4, J5, J6, J7, J8: AudioJack2_SwitchT; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
J9: PJ366ST
J10: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical
J11: Conn_01x05; PinSocket_1x05_P2.54mm_Vertical
Q1, Q2: 2N3904; SOT-23-3
R1, R2: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
S1: PEC11R-4215F-S0024; Rotary_Encoder_Switched_PEC11R
S2: B3U-1000P; Switch_Tactile_SMD_B3U-1000P
SW1, SW2: SW_Push; PBS-105
SW3, SW4: SW_SPST; ToggleSwitch_MTS-101_SPST
U1: Pico; RPi_Pico_Pinheaders
U2: 4504; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
/3V3: J11.4, U1.36 (3V3), U2.1 (VCC)
/5V: C1.1, C2.1, D1.1 (K), D4.1 (K), D5.1 (K), J11.3, U1.39 (VSYS), U2.16 (VDD)
/D Out 1: R5.2, U2.6 (Cout)
/D Out 2: R6.2, U2.10 (Dout)
/D Out 3: R15.2, U2.12 (Eout)
/D Out 4: R16.2, U2.15 (Fout)
/PWM Out 1: R3.2, U2.2 (Aout)
/PWM Out 2: R4.2, U2.4 (Bout)
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, D2.2 (A), D3.2 (A), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), H1.3, H1.4, H1.5, H1.6, H1.7, H1.8, J1.S, J2.S, J3.S, J4.S, J5.S, J6.S, J7.S, J8.S, J11.5, Q1.2 (E), Q2.2 (E), S1.2, S1.C (COM), S2.1, SW1.1, SW2.1, SW3.1 (A), SW4.1 (A), U1.23 (GND), U1.38 (GND), U2.8 (VSS), U2.13 (Select)
unnamed: C3.2, J4.T, R3.1
unnamed: C4.2, J3.T, R4.1
unnamed: C5.2, J5.T, R5.1
unnamed: C6.2, J6.T, R6.1
unnamed: C7.2, J7.T, R15.1
unnamed: C8.2, J8.T, R16.1
unnamed: D1.2 (A), D2.1 (K), J9.2, J10.2
unnamed: D3.1 (K), D4.2 (A), J9.3, J10.1
unnamed: D5.2 (A), H1.11, H1.12
unnamed: D6.2 (A), R7.2
unnamed: D7.2 (A), R8.2
unnamed: D8.2 (A), R9.2
unnamed: D9.2 (A), R10.2
unnamed: D10.2 (A), R11.2
unnamed: D11.2 (A), R12.2
unnamed: D12.2 (A), R13.2
unnamed: D13.2 (A), R14.2
unnamed: J1.T, R1.2
unnamed: J2.T, R2.2
unnamed: J9.1, J10.3
unnamed: J11.1, U1.2 (GPIO1)
unnamed: J11.2, U1.1 (GPIO0)
unnamed: Q1.1 (B), R1.1
unnamed: Q1.3 (C), U1.11 (GPIO8)
unnamed: Q2.1 (B), R2.1
unnamed: Q2.3 (C), U1.12 (GPIO9)
unnamed: R7.1, U1.7 (GPIO5)
unnamed: R8.1, U1.6 (GPIO4)
unnamed: R9.1, U1.5 (GPIO3)
unnamed: R10.1, U1.4 (GPIO2)
unnamed: R11.1, U1.34 (GPIO28_ADC2)
unnamed: R12.1, U1.32 (GPIO27_ADC1)
unnamed: R13.1, U1.31 (GPIO26_ADC0)
unnamed: R14.1, U1.29 (GPIO22)
unnamed: S1.1, U1.10 (GPIO7)
unnamed: S1.A (CH_A), U1.17 (GPIO13)
unnamed: S1.B (CH_B), U1.16 (GPIO12)
unnamed: S2.2, U1.30 (RUN)
unnamed: SW1.2, U1.14 (GPIO10)
unnamed: SW2.2, U1.15 (GPIO11)
unnamed: SW3.2 (B), U1.19 (GPIO14)
unnamed: SW4.2 (B), U1.20 (GPIO15)
unnamed: U1.21 (GPIO16), U2.14 (Fin)
unnamed: U1.22 (GPIO17), U2.11 (Ein)
unnamed: U1.24 (GPIO18), U2.9 (Din)
unnamed: U1.25 (GPIO19), U2.7 (Cin)
unnamed: U1.26 (GPIO20), U2.5 (Bin)
unnamed: U1.27 (GPIO21), U2.3 (Ain)

File hardware/version0.1/useqBOM-v0.1.csv:

Source:,/home/ck84/Documents/modular/cephlasonic/useq/useq.kicad_sch,,,,,,,,,,,,,,,
Date:,Mon 13 Mar 2023 15:43:46 GMT,,,,,,,,,,,,,,,
Tool:,Eeschema 6.0.2+dfsg-1,,,,,,,,,,,,,,,
Generator:,/usr/share/kicad/plugins/bom_csv_grouped_by_value.py,,,,,,,,,,,,,,,
Component Count:,57,,,,,,,,,,,,,,,
,,,,,,,,,,,,,,,,
,,,,,,,,,,,,,,,,
,,,,,,,,,,,,,,,,
Collated Components:,,,,,,,,,,,,,,,,
,,,,,,,,,,,,,,,,
Item,Qty,Reference(s),,Value,LibPart,Footprint,Datasheet,Category,DK_Datasheet_Link,DK_Detail_Page,Description,Digi-Key_PN,Family,MPN,Manufacturer,Status
1,1,C1,,10u,Device:C,Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder,~,,,,,,,,,
2,1,C2,,100n,Device:C,Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder,~,,,,,,,,,
3,2,"C3, C4",,4.7n,Device:C,Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder,~,,,,,,,,,
4,4,"C5, C6, C7, C8",,(4.7n),Device:C,Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder,~,,,,,,,,,
5,5,"D1, D2, D3, D4, D5",,1N5819,Diode:1N5818,Diode_SMD:D_SOD-123,http://www.vishay.com/docs/88525/1n5817.pdf,,,,,,,,,
6,8,"D6, D7, D8, D9, D10, D11, D12, D13",,LED,Device:LED,LED_THT:LED_D3.0mm,~,,,,,,,,,
7,1,H1,,PIN_HEADER_2x8,eurocad:PIN_HEADER_2x8,Connector_IDC:IDC-Header_2x08_P2.54mm_Vertical,,,,,,,,,,
8,8,"J1, J2, J3, J4, J5, J6, J7, J8",,AudioJack2_SwitchT,Connector:AudioJack2_SwitchT,Connector_Audio:Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles,~,,,,,,,,,
9,1,J9,,PJ366ST,w_connector:PJ366ST,w_connector:PJ366ST,https://www.thonk.co.uk/shop/3-5mm-jacks/,,,,,,,,,
10,,,,,,,,,,,,,,,,
11,2,"Q1, Q2",,2N3904,dk_Transistors-Bipolar-BJT-Single:2N3904,Package_TO_SOT_SMD:SOT-23,https://my.centralsemi.com/get_document.php?cmp=1&mergetype=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,Discrete Semiconductor Products,https://my.centralsemi.com/get_document.php?cmp=1&mergetype=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,/product-detail/en/central-semiconductor-corp/2N3904/2N3904CS-ND/4806876,TRANS NPN 40V TO-92,2N3904CS-ND,Transistors - Bipolar (BJT) - Single,2N3904,Central Semiconductor Corp,Active
12,2,"R1, R2",,100k,Device:R,Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder,~,,,,,,,,,
13,2,"R3, R4",,2k2,Device:R,Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder,~,,,,,,,,,
14,4,"R5, R6, R15, R16",,1k or 2.2k,Device:R,Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder,~,,,,,,,,,
15,8,"R7, R8, R9, R10, R11, R12, R13, R14",,1k,Device:R,Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder,~,,,,,,,,,
16,1,S1,,PEC11R-4215F-S0024,dk_Encoders:PEC11R-4215F-S0024,digikey-footprints:Rotary_Encoder_Switched_PEC11R,https://www.bourns.com/docs/Product-Datasheets/PEC11R.pdf,"Sensors, Transducers",https://www.bourns.com/docs/Product-Datasheets/PEC11R.pdf,/product-detail/en/bourns-inc/PEC11R-4215F-S0024/PEC11R-4215F-S0024-ND/4499665,ROTARY ENCODER MECHANICAL 24PPR,PEC11R-4215F-S0024-ND,Encoders,PEC11R-4215F-S0024,Bourns Inc.,Active
17,1,S2,,B3U-1000P,dk_Tactile-Switches:B3U-1000P,digikey-footprints:Switch_Tactile_SMD_B3U-1000P,https://omronfs.omron.com/en_US/ecb/products/pdf/en-b3u.pdf,Switches,https://omronfs.omron.com/en_US/ecb/products/pdf/en-b3u.pdf,/product-detail/en/omron-electronics-inc-emc-div/B3U-1000P/SW1020CT-ND/1534357,SWITCH TACTILE SPST-NO 0.05A 12V,SW1020CT-ND,Tactile Switches,B3U-1000P,Omron Electronics Inc-EMC Div,Active
18,2,"SW1, SW2",,SW_Push,Switch:SW_Push,Eurocad:PBS-105,~,,,,,,,,,
19,1,SW3,,SW_SPST,Switch:SW_SPST,benjiaomodular:ToggleSwitch_MTS-101_SPST,~,,,,,,,,,
20,1,U1,,Pico,MCU_RaspberryPi_and_Boards:Pico,MCU_RaspberryPi_and_Boards:RPi_Pico_Pinheaders,,,,,,,,,,
21,1,U2,,4504,4xxx:4504,Package_SO:SOIC-16_3.9x9.9mm_P1.27mm,http://www.ti.com/lit/ds/symlink/cd4504b.pdf,,,,,,,,,
,,,,,,,,,,,,,,,,
,1,pin headers female 20 pin,,2.54mm vertical,,,,,,,,,,,,
,1,pin headers male 20 pin,,2.54mm vertical,,,,,,,,,,,,
,1,pin headers female 3 pin,,2.54mm vertical,,,,,,,,,,,,
,1,pin headers male 3 pin,,2.54mm vertical,,,,,,,,,,,,
