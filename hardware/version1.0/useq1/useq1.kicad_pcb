File: hardware/version1.0/useq1/useq1.kicad_pcb (KiCad board)
At the start: 2 copper layers, 40.6 x 108 mm, 172 parts, among them J1 Hanbo_USB_C_Receptacle_USB2.0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, J10 Out A2, J11 Out A3, J12 Out D1, J13 Out D2, J14 Out D3, J15 SWD, J2 Gate In 1, J3 Gate In 2, J4 CV In 1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

Commit message: fixed editor cx issue, added analog ins, labelling on pcb
Routing:
- net Net-(R58-Pad2): track 39.7 -> 38.0 mm
- net +3V3: track 42.7 -> 41.3 mm
Other:
- board text added: "SCL"
- board text added: "SDA"
